# Keil uVision project UartDemo.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32L552ZETxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x30000000,0x00040000) IROM(0x08000000,0x00080000) IROM2(0x0C000000,0x00080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: UartDemo
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0xc000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x30000000 size 0x40000
  group src
    ./: main.c leds.c leds.h delay.c delay.h
  group drivers
    ./: gpio.c gpio.h platform.h uart.c uart.h lcd.c lcd.h queue.c queue.h
software components: CMSIS:CORE 5.0.0, Device:STM32Cube HAL:Common 1.0.3, Device:STM32Cube HAL:Cortex 1.0.3, Device:STM32Cube HAL:DMA 1.0.3, Device:STM32Cube HAL:Flash 1.0.3, Device:STM32Cube HAL:GPIO 1.0.3, Device:STM32Cube HAL:PWR 1.0.3, Device:STM32Cube HAL:RCC 1.0.3, Device:STM32Cube HAL:TIM 1.0.3, Device:STM32Cube HAL:UART 1.0.3, Device:STM32Cube HAL:USART 1.0.3, Device:Startup 1.0.3
