# Keil uVision project ReactionTime.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: ReactionTime
  c flags: Optim=1 wLevel=2
  c include: .\drivers
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group drivers
    ./drivers/: adc.c comparator.c dac.c gpio.c i2c.c timer.c uart.c adc.h comparator.h dac.h gpio.h i2c.h platform.h timer.h uart.h
  group src
    ./src/: main.c leds.c leds.h delay.c
    ../module5/IntReactionTime/src/: delay.h
  group extra
    ./drivers/: stm32f4xx_i2c.h stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_rcc.h
  group ::Device
    RTE/Device/STM32F407VG/: RTE_Device.h startup_stm32f40_41xxx.s system_stm32f4xx.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.3.1
