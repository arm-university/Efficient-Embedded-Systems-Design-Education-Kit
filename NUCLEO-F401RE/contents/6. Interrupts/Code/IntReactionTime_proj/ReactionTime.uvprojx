# Keil uVision project ReactionTime.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ReactionTime
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: .\drivers
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group src
    ./src/: main.c leds.c leds.h delay.c
    ../module5/IntReactionTime/src/: delay.h
  group drivers
    ./drivers/: adc.c adc.h comparator.c comparator.h gpio.c gpio.h i2c.c i2c.h platform.h stm32f4xx_adc.c stm32f4xx_adc.h stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_i2c.c stm32f4xx_i2c.h stm32f4xx_rcc.c stm32f4xx_rcc.h stm32f4xx_usart.c stm32f4xx_usart.h timer.c timer.h uart.c uart.h
software components: CMSIS:CORE 4.3.0, Device:Startup 2.4.2
